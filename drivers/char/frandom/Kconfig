## drivers/char/frandom/Kconfig
```kconfig
#
# frandom (RNG) configuration
#


config HW_FRANDOM
	bool "frandom device"
	default n
	---help---
	frandom: A fast random number generator for Linux.
```
